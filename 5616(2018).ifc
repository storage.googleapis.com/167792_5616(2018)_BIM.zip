Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-05-13T16:22:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 13 16:22:13 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{7917CA16-BED6-43ED-A817-9373CC00F398}\ifc * Database version: 5507 * Database creation date: Mon May 13 16:22:12 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 13 16:22:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 13 16:22:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5616 Washbasin faucet, 5616(2018):5616 Washbasin faucet:356643
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - Projection: 177 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 5616(2018); ConvergoRefNr: 0087-1905-0007-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 11/04/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150089749; EN Standard: EN 817; LVI Number: 6110272; Noise Class: I (ISO 3822); NRF Number: 4200574
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/5616; Catalog Drawing URL: http://static.oras.com/catdrw/5616; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/5616; FDV Document URL: http://www.oras.com/datasheet/5616/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5616; Group: Washbasin faucets; Long Marketing: Oras Clinica wall-mounted washbasin faucet. Firm loop-lever offers good usability to all users and situations. Swivel spout 120° (length=100 mm) with nickel-free waterways and laminar flow. The angle of swiveling can be limited to 60° or it can be locked. In-built limitation options for water temperature and maximum flow-rate. Includes three-time sealed cover plates.; Manufacturer: Oras; Market: INT;FIN;NOR;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 5616 Washbasin faucet; Name_en: 5616 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 278 x 218 x 202; Product Code: 5616; Product Datasheet: http://www.oras.com/datasheet/5616/en; Product Family: Oras Clinica; Product Image URL: http://static.oras.com/image/5616; Product URL: http://static.oras.com/5616; Type Name: 5616 Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Waterways without nickel coating; Aerator: Laminar; Connection: Covered eccentric unions; Connection Size: G3/4; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa With Flow Reducers: 0.00600349 m3/s; Installation and Maintenance: http://static.oras.com/manual/5616; Installation Type: Wall-mounted; Installation Width: CC150± 15 mm; Lever Handle: Loop lever;Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 2 mounting holes; Pressure Loss With Flow 02ls: 170000 Pa; Spare Parts: http://static.oras.com/sp/5616; Spout Swivel Range: 120° (60° / 0°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Health care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5616(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5616; Name: 5616 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 215x224x180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Health Sales Arguments: Surfaces in contact with drinking water do not have a nickel coating.
Pset_ManufacturerTypeInformation - ModelReference: 5616; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5616 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.128908 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00865197 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5616(2018): 5616 Washbasin faucet; Family and Type: 5616(2018): 5616 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5616(2018): 5616 Washbasin faucet; Type Id: 5616(2018): 5616 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
